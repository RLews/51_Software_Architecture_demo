# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=2 SizeSpeed=1
  c include: ..\source\app;..\source\driver;..\source\hal
  group app
    ../source/app/: main.c main.h
  group hal
    ../source/hal/: hal_gpio.c hal_gpio.h hal_timer.c hal_timer.h hal_display.h hal_display.c hal_calendar.h hal_calendar.c hal_paltform.c hal_paltform.h
  group driver
    ../source/driver/: drv_gpio.c drv_gpio.h typedefs.h drv_timer.c drv_timer.h drv_ds1302.c drv_paltform.c drv_lcd.c drv_lcd.h drv_paltform.h drv_ds1302.h
